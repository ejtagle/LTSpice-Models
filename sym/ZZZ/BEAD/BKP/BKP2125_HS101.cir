* BKP2125_HS101     SPICE MODEL  ( General Type )
*--------------------------------------------------------------------------------------------------------
* Model Generated by TAIYO YUDEN Corporation (http://www.Ty-top.com)
* Version 1.0
* TAIYO YUDEN Control No. 070822TG03SB-HCA
*--------------------------------------------------------------------------------------------------------
*
* Products Name : Multilayer Ferrite Chip Beads (for Power Supply Lines)
*
* Characteristics :
*     Impedance at 100MHz : 100 Ohm , DC Resistance(max) : 0.04 Ohm , Rated Current : 2500 mA ,
*     Case Size : 2.0 x 1.25 / 0.079 x 0.049 [mm/inch] , Thickness : 0.85 / 0.033 [mm/inch]
*     (Conditions: Temperature = 25 degC , DC Bias Current/Voltage = 0A / 0V)
*
* External Node Assignments :
*
*  1  o---GGG---o  2
*
*--------------------------------------------------------------------------------------------------------
.SubCkt BKP2125_HS101 1 2
****************************
R1 1 7 0.025
R2 7 2 110
C1 7 2 0.7p
L0 7 3 0.273u
L1 3 2 0.637u
L3 3 5 0.273u
R3 5 2 110
****************************
.ends
